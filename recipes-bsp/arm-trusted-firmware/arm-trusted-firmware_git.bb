include arm-trusted-firmware.inc

SRCREV ?= "87e8aedd80e6448a55b2328768d956fcb5f5d410"

